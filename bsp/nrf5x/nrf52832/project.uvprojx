# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LFS_CONFIG=lfs_config.h, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, NRF52832_XXAA, USE_APP_CONFIG, RT_USING_ARM_LIBC
  c misc: --reduce_paths
  c include: .;applications;..\libraries\cmsis\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\drivers;..\..\..\components\fal\inc;..\..\..\components\dfs\include;..\..\..\components\finsh;.;..\..\..\include;packages\littlefs-latest;packages\nrfx-latest;packages\nrfx-latest\drivers;packages\nrfx-latest\drivers\include;packages\nrfx-latest\mdk;packages\nrfx-latest\hal;packages\nrfx-latest\drivers\src;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    ../libraries/drivers/: drv_flash.c drv_gpio.c drv_uart.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal_rtt.c fal_partition.c fal.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group littlefs
    packages/littlefs-latest/: lfs_crc.c lfs.c lfs_util.c dfs_lfs.c
  group nrf_Drivers
    packages/nrfx-latest/drivers/src/: nrfx_wdt.c nrfx_spim.c nrfx_ppi.c nrfx_systick.c nrfx_gpiote.c nrfx_nvmc.c nrfx_twim.c nrfx_twis.c nrfx_nfct.c nrfx_qdec.c nrfx_clock.c nrfx_spis.c nrfx_dppi.c nrfx_ipc.c nrfx_pwm.c nrfx_uart.c nrfx_lpcomp.c nrfx_usbreg.c nrfx_uarte.c nrfx_comp.c nrfx_temp.c nrfx_rtc.c nrfx_rng.c nrfx_power.c nrfx_pdm.c nrfx_egu.c nrfx_timer.c nrfx_usbd.c nrfx_saadc.c nrfx_adc.c nrfx_twi_twim.c nrfx_qspi.c nrfx_twi.c nrfx_i2s.c nrfx_spi.c
    packages/nrfx-latest/mdk/: system_nrf52.c arm_startup_nrf52.s
